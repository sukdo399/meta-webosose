# Copyright (c) 2017-2019 LG Electronics, Inc.

EXTENDPRAUTO_append = "webos2"

RDEPENDS_${PN}_remove = "update-rc.d"
